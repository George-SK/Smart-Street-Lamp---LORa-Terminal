# Keil uVision project LoRaMac.uvprojx, settings and files
target LoRaMac-433 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433
  c include: ..\..\..\..\src;..\..\..\..\src\boards\EmdoorNode;..\..\..\..\src\boards\EmdoorNode\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../../src/apps/LoRaMac/classA/EmdoorNode/: main.c
  group boards\EmdoorNode
    ../../../../src/boards/EmdoorNode/: board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
  group boards\EmdoorNode\cmsis
    ../../../../src/boards/EmdoorNode/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../../src/boards/EmdoorNode/cmsis/: system_stm32l1xx.c
  group boards\EmdoorNode\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
target LoRaMac-433-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_BOOTLOADER
  c include: ..\..\..\..\src;..\..\..\..\src\boards\SensorNode;..\..\..\..\src\boards\SensorNode\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-780 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-780-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-868 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-868-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-915-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-470 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_470
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-470-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_470 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.0.0
